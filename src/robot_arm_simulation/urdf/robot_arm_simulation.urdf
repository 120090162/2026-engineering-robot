Commit message: 完成上电

File: src/robot_arm_simulation/urdf/robot_arm_simulation.urdf (robot description, URDF)
Before this commit: robot robot_arm_simulation, 8 links, 7 joints
Joints:
- joint joint6: limit lower=-3.14 upper=3.14 effort=0 velocity=0 -> lower=0.0 upper=0.0 effort=0 velocity=0
